# Keil uVision project MDK.uvprojx, settings and files
target MDK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4A6RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: MDK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L4A6xx,USE_HAL_DRIVER,STM32L4A6xx
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\Drivers\Components\HTS221;..\Drivers\Components\LSM6DSL;..\Drivers\Components\STC3115;..\Middlewares\ST\BlueNRG-MS\includes;..\Middlewares\ST\BlueNRG-MS\hci\hci_tl_patterns\Basic;..\Middlewares\ST\BlueNRG-MS\utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32l4a6xx.s
  group uSD
    ../Src/: bsp_driver_sd.c sd_diskio.c fatfs.c
    ../Inc/: bsp_driver_sd.h sd_diskio.h fatfs.h
  group Audio
    ../Src/: Acquisition_Audio.c DFSDM.c
    ../Inc/: Acquisition_Audio.h DFSDM.h
  group RTC
    ../Src/: RTC.c
    ../Inc/: RTC.h
  group Pwr
    ../Src/: PWR.c
    ../Inc/: PWR.h
  group Crypt
    ../Src/: Crypt.c random_key.c
    ../Inc/: Crypt.h random_key.h
  group Bus
    ../Src/: I2C_com.c UART_com.c UART_DEBUG.c SPI_bus.c
    ../Inc/: I2C_com.h UART_com.h UART_DEBUG.h SPI_bus.h
  group Sensor_stm_drivers
    ../Drivers/Components/HTS221/: hts221.c HTS221_env_sensor.c HTS221_env_sensor_ex.c hts221_reg.c
    ../Drivers/Components/LSM6DSL/: lsm6dsl.c LSM6DSL_motion_sensor.c LSM6DSL_motion_sensor_ex.c lsm6dsl_reg.c
  group Sensors_Acquisition
    ../Src/: sensor_acquisition.c Acc_Gyr.c Temp_Hum.c Bat_Monitor.c
    ../Inc/: sensor_acquisition.h Acc_Gyr.h Temp_Hum.h Bat_Monitor.h
  group STC3115-Moniteur_bat
    ../Drivers/Components/STC3115/: stc3115_Battery.h stc3115_Driver.c stc3115_Driver.h stc3115_I2C.c stc3115_I2C.h
  group Application/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c IHM.c GPIO.c
    ../Inc/: main.h stm32l4xx_it.h IHM.h GPIO.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group BLE_APP
    ../Src/: app_x-cube-ble1.c BLE_Com.c gatt_db.c hci_tl_interface.c
    ../Inc/: app_x-cube-ble1.h BLE_Com.h gatt_db.h hci_tl_interface.h ble_list_utils.h bluenrg_conf.h custom_conf.h
  group Middlewares/BlueNRG-MS/Wireless/Controller
    ../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/Wireless/HCI_TL/Basic
    ../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/Wireless/Utils
    ../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
software components: CMSIS:CORE 4.3.0
